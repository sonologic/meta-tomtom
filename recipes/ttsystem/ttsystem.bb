SUMMARY = "Create ttimage file"
DESCRIPTION = "Combines kernel image and root fs into ttsystem."
LICENSE = "GPLv2"
SECTION = "image"

DEPENDS = "mkttimage-native virtual/kernel core-image-minimal"

do_compile() {
}
